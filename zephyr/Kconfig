## zephyr/Kconfig
```kconfig
# Copyright (c) 2024 Intel Corporation
# SPDX-License-Identifier: Apache-2.0

config MCTP
	bool "Enable MCTP"
	help
	  Build libmctp module during build process.
```
